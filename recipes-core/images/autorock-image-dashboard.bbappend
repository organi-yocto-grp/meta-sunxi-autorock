
IMAGE_FSTYPES += "squashfs"

IMAGE_INSTALL_append_a20navi-njgdbus += " dashboard-njgdbus memtester"
IMAGE_INSTALL_append_a20navi-huatai-b11 += " dashboard-huatai-b11"
IMAGE_INSTALL_append_a20navi-haval-h6-10inch += " dashboard-haval-h6-10inch"
