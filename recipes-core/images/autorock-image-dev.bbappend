
IMAGE_FSTYPES += "ubifs"

# should be added as qtbase-plugins dependance
IMAGE_INSTALL += "sunxi-mali"
IMAGE_INSTALL += "emconfig mksplash packimg"

