EXTRA_LINKER_FLAGS += "-static-libgcc"
EGLFS_GPU = "eglfs_mail"
